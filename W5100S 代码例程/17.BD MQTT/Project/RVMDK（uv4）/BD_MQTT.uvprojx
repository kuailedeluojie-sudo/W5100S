# Keil uVision project BD_MQTT.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BD_MQTT +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5100S;..\..\User\FSMC;..\..\User\Usart;..\..\User\TimBase;..\..\User\Ethernet\APP;..\..\User\flash;..\..\User\SPI;..\..\User\Ethernet\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c bsp_usart1.h
    ../../User/FSMC/: bsp_fsmc.c bsp_fsmc.h
    ../../User/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
    ../../User/flash/: bsp_flash.c bsp_flash.h
    ../../User/SPI/: bsp_spi.c bsp_spi.h
  group W5100S
    ../../User/Ethernet/W5100S/: types.h socket.c socket.h w5100s.c w5100s.h wizchip_conf.c wizchip_conf.h w5100s_conf.c w5100s_conf.h utility.c utility.h
  group APP
    ../../User/Ethernet/APP/: dhcp.c dhcp.h tcp_client.c tcp_client.h
  group MQTT
    ../../User/Ethernet/MQTT/: BD_TG.c BD_TG.h MqttKit.c MqttKit.h
